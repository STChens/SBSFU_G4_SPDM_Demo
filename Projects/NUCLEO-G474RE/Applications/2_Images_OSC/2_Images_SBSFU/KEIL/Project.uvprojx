# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G474RE_2_Images_SBSFU (6210000::V6.21::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.6
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SBSFU
  BeforeMake: ..\..\2_Images_SECoreBin\KEIL\prebuild.bat ..\..\2_Images_SECoreBin\KEIL\ 1
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G474xx,USE_HAL_DRIVER,USE_STM32G4XX_NUCLEO,USE_NUCLEO_64, SBSFU_SINGLE_PROJECT, __NOT_USED_KEY_REVOCATION, MBEDTLS_CONFIG_FILE=<se_mbedtls_config.h>
  c misc: -Wno-format
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32G4xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../Core/Inc;../SBSFU/App;../SBSFU/Target;../../2_Images_SECoreBin/Inc;..\..\Linker_Common\KEIL;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Interface;..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Key;..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include;..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include\mbedtls
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: Project.sct
  group Application/Core
    ../Core/Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
    ./: sfu_se_mpu.s
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_loader.c sfu_boot.c sfu_com_loader.c sfu_com_trace.c sfu_error.c sfu_test.c sfu_fwimg_common.c sfu_fwimg_swap.c sfu_fwimg_no_swap.c sfu_new_image.c sfu_mpu_isolation.c
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level_security.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_exti.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c se_callgate.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c
  group SECoreBin/MDK_ARM
    ../../2_Images_SECoreBin/KEIL/: se_key.s
  group SECoreBin/User
    ../../2_Images_SECoreBin/Src/: se_crypto_bootloader.c se_low_level.c
  group Middleware/Third_Party/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c bignum.c camellia.c cipher.c ecdsa.c ecp.c ecp_curves.c gcm.c md.c platform.c platform_util.c sha256.c sha512.c cipher_wrap.c asn1parse.c asn1write.c hmac_drbg.c md_wrap.c
software components: CMSIS:CORE 5.4.0
