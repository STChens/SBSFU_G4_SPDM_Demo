# IAR project Project.ewp, settings and files
configuration NUCLEO-G474RE_2_Images_SECoreBin (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G474xx; USE_HAL_DRIVER; USE_STM32G4XX_NUCLEO; USE_NUCLEO_64; KEY_REVOCATION
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\..\..\..\Drivers\STM32G4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Key; ..\..\2_Images_SBSFU\SBSFU\App; ..\..\2_Images_SBSFU\SBSFU\Target; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32G4\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\SE_Core.bin
  prebuild: cmd /C "cmd /C prebuild.bat "$PROJ_DIR$" 8"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: SE_CallGate
  group Application/EWARM
    ./: se_key.s
  group Application/User
    ../Src/: se_crypto_bootloader.c se_low_level.c
  group Doc
    ../: readme.txt
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32G4/Lib/: STM32CryptographicV3.1.3_CM4_IARv8.a
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_crypto_common.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c
