# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G474RE_2_Images_UserApp (6210000::V6.21::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.6
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . #L .\@L.bin 1 1 8  0
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G474xx,USE_HAL_DRIVER,USE_STM32G4XX_NUCLEO,SPDM_DEMO,STSAFE_A110
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32G4xx_Nucleo;../../2_Images_SBSFU/SBSFU/App;../SBSFU/Target;../../2_Images_SECoreBin/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../Linker_Common/MDK-ARM;..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\X509\Inc;..\Inc\spdm;..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32G4\Inc;..\..\..\..\..\..\Middlewares\ST\STSAFE_Axx0\Interface;..\..\..\..\..\..\Middlewares\ST\STSAFE_Axx0\CoreModules\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: Project.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: fw_update_app.c common.c se_user_code.c test_protections.c main.c flash_if.c stm32g4xx_it.c com.c ymodem.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Drivers/BSP/STM32G4xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/NUCLEO-G474RE/Exe/: se_interface_appli.txt
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_dma.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_rcc.c stm32g4xx_hal_cortex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_crc.c stm32g4xx_hal_uart.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_rtc.c stm32g4xx_hal_exti.c stm32g4xx_hal.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c
  group Application/SPDM_Demo
    ../Src/spdm/: spdm_handler.c stm32g4xx_nucleo_bus.c stm32g4xx_nucleo_crc.c stsafea_crypto_interface.c stsafea_service_interface.c
  group Middlewares/STSAFE-A1xx
    ../../../../../../Middlewares/ST/STSAFE_Axx0/CoreModules/Src/: stsafea_core.c stsafea_crypto.c stsafea_service.c
  group Middlewares/STM32_Cryptolib
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32G4/Lib/: STM32CryptographicV3.1.3_CM4_KEIL_ot1elfspf.lib
software components: CMSIS:CORE 5.4.0
