# IAR project Project.ewp, settings and files
configuration NUCLEO-G474RE_2_Images_UserApp (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G474xx; USE_HAL_DRIVER; SPDM_DEMO; STSAFE_A110
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\..\..\..\Drivers\STM32G4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\2_Images_SECoreBin\Inc; ..\..\2_Images_SBSFU\SBSFU\App; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Drivers\BSP\STM32G4xx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STSAFE_Axx0\Interface; ..\..\..\..\..\..\Middlewares\ST\STSAFE_Axx0\CoreModules\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32G4\Inc; ..\Inc\spdm; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\X509\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\UserApp.bin
  postbuild: cmd /C "cmd /C ..\..\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "UserApp.bin" 1 1 8 0"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/User
    ../Src/: com.c common.c flash_if.c fw_update_app.c main.c se_user_code.c stm32g4xx_it.c test_protections.c ymodem.c
  group Application/User/spdm
    ../Src/spdm/: spdm_handler.c stm32g4xx_nucleo_bus.c stm32g4xx_nucleo_crc.c stsafea_crypto_interface.c stsafea_service_interface.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Middlewares/STM32_Cryptolib
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32G4/Lib/: STM32CryptographicV3.1.3_CM4_IARv8.a
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/EWARM/: se_interface_appli.o
  group Middlewares/STSAFE-A1xx
    ../../../../../../Middlewares/ST/STSAFE_Axx0/CoreModules/Src/: stsafea_core.c stsafea_crypto.c stsafea_service.c
